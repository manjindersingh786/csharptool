# Keil uVision project THC80F340A_SC000_DEMO.uvprojx, settings and files
target THC80F340A_DEMO (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: THC80F340A_SC000_DEMO +hex
  c flags: Optim=4 v6Lang=1 v6LangP=5 wLevel=3
  c include: ..\THC80F480A_SC000_DEMO;.\SC000_SYS;.\ISO7816;.\NORFlash
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SC000_SYS\scat.scf
  group SC000_SYS
    ./SC000_SYS/: SC000_Vect.s SC000_Init.s Main.c Memory_API.c SC000_ISR.c SC_API.c SC_SFR.h THC80ASM.H
  group ISO7816
    ./ISO7816/: ISO7816_Main.c ISO7816_API.c ISO7816.h
  group NORFlash
    ./NORFlash/: NORFlash.c NORFlash.h
software components: CMSIS:CORE 5.6.0
