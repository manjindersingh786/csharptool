# Keil uVision project Oasis.uvprojx, settings and files
target THC80F340A_DBG (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Oasis +hex
  AfterMake: fromelf $PObjects\%L --disassemble --interleave=source  --text -c --output=outfile.lst
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: _CHIP_THC80F340A,SIZE_CODE=0xDA00,FEAT_EXHAUSTEARING,NO_OF_SPARE_PAGES_FOR_EXHASUTEARING=0x05
  c include: .\BusinessComponent\Telecom\51_011\include;.\HardwareLayers\Abstraction\Include;.\Core\CommandRouter\include;.\HardwareLayers\Abstraction\7816_3\include;.\Core\7816_4\include;.\Core\102_222\include;.\Core\102_221\include;.\Core\MemoryManager\include;.\ExceptionManager\CoreExceptionManager\include;.\Core\OS_Init\include;.\Core\7816_9\include;.\BusinessComponent\Telecom\51_011\include;.\Core\Algorithms\include;.\Core\OasisCommands\include;.\HardwareLayers\HAL_THC80F340A\Include;.\HardwareLayers\HAL_THC80F340A\Startup\ISO7816;.\HardwareLayers\HAL_THC80F340A\Startup\NORFlash;.\HardwareLayers\HAL_THC80F340A\Startup\SC000_SYS;.\Core\ChannelManager\include;.\BusinessComponent\Telecom\31_102\include;.\BusinessComponent\Telecom\31_111\include;.\Core\102_225\include;.\Core\102_226\include;.\BusinessComponent\Telecom\31_115\include;.\BusinessComponent\Telecom\31_116\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\HardwareLayers\HAL_THC80F340A\Oasis_THC80F340A.scf
  group HAL_THC80F340A
    ./HardwareLayers/HAL_THC80F340A/: Chip_THC80F340A_ReadWrite.c Chip_THC80F340A_ISO7816.c
    ./HardwareLayers/Abstraction/: Main.c Oasis.c
    ./HardwareLayers/Abstraction/Include/: BitDefines.h Constants.h Debug.h Main.h MemoryWrappers.h Oasis.h types.h WrappersExtern.h
    ./HardwareLayers/HAL_THC80F340A/Include/: ChipConfig.h ChipExtern.h ChipLowLevel.h ChipTearing.h
    ./HardwareLayers/HAL_THC80F340A/Startup/ISO7816/: ISO7816.h ISO7816_API.c ISO7816_Main.c
    ./HardwareLayers/HAL_THC80F340A/Startup/NORFlash/: NORFlash.c NORFlash.h
    ./HardwareLayers/HAL_THC80F340A/Startup/SC000_SYS/: Memory_API.c SC_API.c SC_SFR.h SC000_Init.s SC000_ISR.c SC000_Vect.s THC80ASM.H TSIM.h THC80_Main.c
  group CoreExceptionManager
    ./ExceptionManager/CoreExceptionManager/source/: ExceptionHandling.c
    ./ExceptionManager/CoreExceptionManager/include/: ExceptionHandling.h ExceptionHandling_extern.h
  group ChannelManager
    ./Core/ChannelManager/include/: channelManager.h channelManager_extern.h
    ./Core/ChannelManager/source/: channelManager.c
  group CommandRouter
    ./Core/CommandRouter/source/: CommandRouter.c
    ./Core/CommandRouter/include/: CommandRouter.h CommandRouterExtern.h
  group MemoryManager
    ./Core/MemoryManager/source/: MemoryManager.c Utilities.c
    ./Core/MemoryManager/include/: MemoryLayout.h MemoryManager.h MemoryManager_extern.h SystemPage.h
  group OasisCommands
    ./Core/OasisCommands/source/: oasis_GenericCommands.c
    ./Core/OasisCommands/include/: OasisCommands.h OasisCommands_extern.h
  group OS_Init
    ./Core/OS_Init/source/: OSinit.c
    ./Core/OS_Init/include/: OSinit.h OSinit_extern.h
  group 102_221
    ./Core/102_221/source/: 102_221.c CatCommands.c FileHandlingCommands.c GenericCommands.c PinManagementCommands.c TransmissionCommands.c UICC_CommandDispatcher.c
    ./Core/102_221/include/: 102_221.h 102_221_extern.h UICC_CommandDispatcher.h UICC_CommandDispatcher_extern.h
  group 102_222
    ./Core/102_222/include/: 102_222.h 102_222_extern.h
    ./Core/102_222/source/: 102_222.c
  group 7816_4
    ./Core/7816_4/source/: 7816_4.c PinManagement.c StatusWords.c
    ./Core/7816_4/include/: 7816_4.h 7816_4_extern.h statuswords.h
  group 7816_9
    ./Core/7816_9/source/: 7816_9.c
    ./Core/7816_9/include/: 7816_9.h 7816_9_extern.h
  group Algorithms
    ./Core/Algorithms/include/: Algorithms.h Algorithms_extern.h
    ./Core/Algorithms/source/: algo_comp128.c algo_milenage.c algo_AES.c algo.c algo_3DES.c algo_aes_128.c algo_AES_CMAC.c algo_BlockCipher.c algo_Checksum.c algo_CRC.c algo_DES.c algo_Signature.c
  group 31_102
    ./BusinessComponent/Telecom/31_102/include/: 31_102.h 31_102_extern.h
    ./BusinessComponent/Telecom/31_102/source/: usim_GenericCommands.c
  group 31_111
    ./BusinessComponent/Telecom/31_111/include/: 31_111.h 31_111_extern.h
    ./BusinessComponent/Telecom/31_111/source/: 31_111.c USIM_CatHandling.c
  group 51_011
    ./BusinessComponent/Telecom/51_011/source/: sim_CatCommands.c sim_FileHandlingCommands.c sim_GenericCommands.c sim_PinManagementCommands.c
    ./BusinessComponent/Telecom/51_011/include/: 51_011.h 51_011_extern.h
  group AntiTearing
    ./HardwareLayers/Abstraction/Include/: AntiTearing.h AntiTearing_extern.h
    ./HardwareLayers/Abstraction/AntiTearing/: AntiTearing.c
  group Wrappers
    ./HardwareLayers/Abstraction/Wrappers/: readUpdateNvmWrappers.c
  group 7816_3
    ./HardwareLayers/Abstraction/7816_3/source/: ATR.c Communication.c
    ./HardwareLayers/Abstraction/7816_3/include/: 7816_3.h 7816_3_extern.h
  group 102_225
    ./Core/102_225/source/: 102_225.c
    ./Core/102_225/include/: 102_225.h 102_225_extern.h
  group 102_226
    ./Core/102_226/source/: 102_226.c Rfm.c
    ./Core/102_226/include/: 102_226.h 102_226_extern.h
  group 31_115
    ./BusinessComponent/Telecom/31_115/include/: 31_115.h 31_115_extern.h
    ./BusinessComponent/Telecom/31_115/source/: 31_115.c
  group 31_116
    ./BusinessComponent/Telecom/31_116/source/: 31_116.c
    ./BusinessComponent/Telecom/31_116/include/: 31_116.h 31_116_extern.h
