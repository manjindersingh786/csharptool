#include "memory.h"

typedef unsigned char uMonoByte;
typedef uMonoByte* puMonoByte;
static const uMonoByte umbTable0[256] = { 0xc5, 0xeb, 0x3c, 0x97, 0x62, 0x60, 0x03, 0x64, 0xf8, 0x76, 0x2a, 0x75, 0xac, 0xd3, 0xb5, 0xcb, 0x3d, 0x7e, 0x9c, 0x57, 0x95, 0xe0, 0x37, 0x84, 0xba, 0x3f, 0xee, 0xff, 0x55, 0x53, 0x98, 0x21, 0xa0, 0xb8, 0xd2, 0xdb, 0x9f, 0x0b, 0xb4, 0xc2, 0x82, 0xd4, 0x93, 0x05, 0xd7, 0x5c, 0x1b, 0x2e, 0x71, 0xbb, 0x34, 0x19, 0xb9, 0x4f, 0xdd, 0x30, 0x46, 0x1f, 0x65, 0x0f, 0xc3, 0xc9, 0x32, 0xde, 0x89, 0xe9, 0xe5, 0x6a, 0x7a, 0xb7, 0xb2, 0xb1, 0x90, 0xcf, 0xea, 0xb6, 0x25, 0xfe, 0xe3, 0xe7, 0x36, 0xd1, 0x85, 0x41, 0xca, 0x45, 0xed, 0xdc, 0xbd, 0x92, 0x78, 0x44, 0x15, 0x7d, 0x26, 0x1e, 0x02, 0x9b, 0x35, 0xc4, 0xae, 0xb0, 0x33, 0xf6, 0xa7, 0x4c, 0x6e, 0x14, 0x52, 0x79, 0x67, 0x70, 0x38, 0xad, 0x31, 0xd9, 0xfc, 0x00, 0x72, 0xe4, 0x7b, 0x0c, 0x5d, 0xa1, 0xfd, 0xe8, 0xf0, 0xaf, 0x43, 0x80, 0x16, 0x9e, 0x59, 0x12, 0x4d, 0x6d, 0xbe, 0x11, 0x3e, 0x04, 0x99, 0xa3, 0x3b, 0x91, 0x8a, 0x07, 0x4a, 0xcd, 0x0a, 0xa2, 0x50, 0x2d, 0x68, 0x6f, 0x96, 0xd6, 0x9a, 0x1c, 0xbf, 0xa9, 0xd5, 0x58, 0xc1, 0xc6, 0xc8, 0xf5, 0x27, 0xa4, 0x7c, 0x54, 0x4e, 0x01, 0xbc, 0xaa, 0x17, 0x56, 0xe2, 0x8d, 0x20, 0x06, 0x83, 0x7f, 0xc7, 0x28, 0x87, 0x10, 0x39, 0x47, 0x5b, 0xe1, 0xa8, 0xf2, 0xce, 0x61, 0xa6, 0x2c, 0x0e, 0x5a, 0xec, 0xef, 0xe6, 0xf4, 0xdf, 0x6c, 0x66, 0x77, 0x94, 0xfb, 0x1d, 0xd8, 0x08, 0x09, 0xf9, 0xd0, 0x18, 0x69, 0x5e, 0x22, 0x40, 0x5f, 0x73, 0x48, 0x86, 0xcc, 0x2b, 0xf7, 0xf3, 0xda, 0x2f, 0x3a, 0x49, 0x6b, 0xf1, 0xb3, 0x74, 0x42, 0x24, 0x8f, 0x51, 0xfa, 0x8b, 0x13, 0x0d, 0x8e, 0x8c, 0x81, 0xc0, 0x63, 0xab, 0x9d, 0x88, 0x29, 0x4b, 0x23, 0xa5, 0x1a
};
static const uMonoByte umbTable1[256] = { 0xaa, 0x2a, 0x5f, 0x8d, 0x6d, 0x1e, 0x47, 0x59, 0x1a, 0x93, 0xe7, 0xcd, 0xef, 0xd4, 0x7c, 0x81, 0xd8, 0x4f, 0x0f, 0xb9, 0x99, 0x0e, 0xfb, 0xa2, 0x00, 0xf1, 0xac, 0xc5, 0x2b, 0x0a, 0xc2, 0xeb, 0x06, 0x14, 0x48, 0x2d, 0x8f, 0x68, 0xa1, 0x77, 0x29, 0x88, 0x26, 0xbd, 0x87, 0x19, 0x5d, 0x12, 0xe0, 0xab, 0xfc, 0xc3, 0x3f, 0x13, 0x3a, 0xa5, 0x17, 0x37, 0x85, 0xfe, 0xd6, 0x90, 0xdc, 0xb2, 0x9c, 0x34, 0x6e, 0xe1, 0x61, 0xb7, 0x8c, 0x27, 0x35, 0x58, 0xdb, 0xa7, 0x10, 0xc6, 0x3e, 0xde, 0x4c, 0x8b, 0xaf, 0x5e, 0x33, 0x86, 0x73, 0x16, 0x43, 0x01, 0xf9, 0xd9, 0x03, 0x05, 0xe8, 0x8a, 0x1f, 0x38, 0x74, 0xa3, 0x46, 0x80, 0xea, 0x84, 0xe5, 0xb8, 0xf4, 0x0d, 0x22, 0x49, 0xe9, 0x9a, 0xb3, 0x83, 0xd7, 0xec, 0x8e, 0xdf, 0x1b, 0x39, 0xf6, 0x6c, 0xd3, 0x08, 0xfd, 0x55, 0x42, 0xf5, 0xc1, 0x4e, 0xbe, 0x04, 0x11, 0x07, 0x96, 0x7f, 0x98, 0xd5, 0x25, 0xba, 0x02, 0xf3, 0x2e, 0xa9, 0x44, 0x65, 0x3c, 0xae, 0xd0, 0x9e, 0xb0, 0x45, 0xee, 0xbf, 0x5a, 0x53, 0xa6, 0x7d, 0x4d, 0x3b, 0x15, 0x5c, 0x31, 0x97, 0xa8, 0x63, 0x09, 0x32, 0x92, 0x71, 0x75, 0xe4, 0x41, 0xe6, 0x28, 0x52, 0x36, 0xed, 0xe3, 0x66, 0x1c, 0x24, 0x6b, 0x18, 0x2c, 0x7e, 0xce, 0xc9, 0x3d, 0x72, 0xa4, 0xcf, 0xb5, 0x1d, 0x5b, 0x40, 0xdd, 0xff, 0x30, 0x9b, 0xc0, 0x6f, 0xb4, 0xd2, 0xb6, 0xf7, 0xcb, 0x94, 0xd1, 0x62, 0xad, 0x0b, 0x4b, 0x7b, 0xfa, 0x76, 0x20, 0x2f, 0xf0, 0xca, 0x4a, 0xb1, 0x64, 0x50, 0xc4, 0x21, 0xf8, 0x56, 0x9d, 0x89, 0x78, 0x82, 0x54, 0xcc, 0x7a, 0x51, 0xf2, 0xbc, 0xc8, 0x95, 0xe2, 0xda, 0xa0, 0xbb, 0x6a, 0x23, 0x57, 0x69, 0x60, 0x91, 0xc7, 0x9f, 0x0c, 0x79, 0x67, 0x70
};


static void algos_comp128v23(puMonoByte pumbOutput, const puMonoByte pumbKxor, const puMonoByte pumbRand)
{
	uMonoByte umbTemp[16];
	uMonoByte umbKmRm[32];
	uMonoByte i, j, k, z;

	memset(umbTemp, 0, sizeof(umbTemp));
	memcpy(umbKmRm, pumbRand, 16);
	memcpy(umbKmRm + 16, pumbKxor, 16);

	for (i = 0; i < 5; i++) {
		for (z = 0; z < 16; z++) {
			umbTemp[z] = umbTable0[umbTable1[umbKmRm[16 + z]] ^ umbKmRm[z]];
		}
		j = 0;
		while ((1 << i) > j) {
			k = 0;
			while ((1 << (4 - i)) > k) {
				umbKmRm[((2 * k + 1) << i) + j] = umbTable0[umbTable1[umbTemp[(k << i) + j]] ^ (umbKmRm[(k << i) + 16 + j])];
				umbKmRm[(k << (i + 1)) + j] = umbTemp[(k << i) + j];
				k++;
			}
			j++;
		}
	}

	memset(pumbOutput, 0, 16);

	for (i = 0; i < 16; i++) {
		for (j = 0; j < 8; j++) {
			pumbOutput[i] ^= (((umbKmRm[(19 * (j + 8 * i) + 19) % 256 / 8] >> (3 * j + 3) % 8) & 1) << j);
		}
	}
}

/* Perform COMP128v3 algorithm
 *  @param [in] pumbKi Secret Key K(i) of subscriber
 *  @param [in] pumbRand pumbRandom Challenge
 *  @param [out] pumbSres user-supplied buffer for storing computed pumbSres value
 *  @param [out] pumbKc user-supplied buffer for storing computed pumbKc value
 *  @return 0
 *
 */
uMonoByte algos_comp128v3(const puMonoByte pumbKi, const puMonoByte pumbRand, puMonoByte pumbSres, puMonoByte pumbKc) {
	uMonoByte umbKmix[16];
	uMonoByte umbRandMix[16];
	uMonoByte umbKatyVasz[16];
	uMonoByte umbOutput[16];
	uMonoByte i;

	memset(umbKmix, 0, sizeof(umbKmix));
	memset(umbRandMix, 0, sizeof(umbRandMix));
	memset(umbKatyVasz, 0, sizeof(umbKatyVasz));
	memset(umbOutput, 0, sizeof(umbOutput));

	for (i = 0; i < 8; i++) {
		umbKmix[i] = pumbKi[15 - i];
		umbKmix[15 - i] = pumbKi[i];
	}

	for (i = 0; i < 8; i++) {
		umbRandMix[i] = pumbRand[15 - i];
		umbRandMix[15 - i] = pumbRand[i];
	}

	for (i = 0; i < 16; i++) {
		umbKatyVasz[i] = umbKmix[i] ^ umbRandMix[i];
	}

	for (i = 0; i < 8; i++) {
		algos_comp128v23(umbRandMix, umbKatyVasz, umbRandMix);
	}

	for (i = 0; i < 16; i++) {
		umbOutput[i] = umbRandMix[15 - i];
	}

	memmove(umbOutput + 4, umbOutput + 8, 8); /* ignore bytes 4..7 */

	/* the algorithm uses 16 bytes until this point, but only 12 bytes are effective
	 * also 12 bytes coming out from the SIM card */
	memcpy(pumbSres, umbOutput, 4);
	memcpy(pumbKc, umbOutput + 4, 8);

	return 0;
}

/* Perform COMP128v2 algorithm
 *  @param [in] pumbKi Secret Key K(i) of subscriber
 *  @param [in] pumbRand pumbRandom Challenge
 *  @param [out] pumbSres user-supplied buffer for storing computed pumbSres value
 *  @param [out] pumbKc user-supplied buffer for storing computed pumbKc value
 *  @return 0
 *
 */
uMonoByte algos_comp128v2(const puMonoByte pumbKi, const puMonoByte pumbRand, puMonoByte pumbSres, puMonoByte pumbKc) {
	uMonoByte r = algos_comp128v3(pumbKi, pumbRand, pumbSres, pumbKc);
	pumbKc[7] = 0; /* 10 last bits of pumbKc forced to 0 */
	pumbKc[6] &= 0xfc;
	return r;
}
